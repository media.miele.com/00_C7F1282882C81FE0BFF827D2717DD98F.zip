Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: d6c314ca-d3f1-471d-8024-df50e33bab81, NumberOfSaves: 1]
File name: 0001
Time: 2026-01-29T12:24:19+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12922340_D_ORD1224WBL:331B2DRW_D_12922340_ORD1224WBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Glass, Spruce, z_Miele_Connection_Connection_Modul
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 331B2DRW_D_12922340_ORD1224WBL; sets with these values: 2
